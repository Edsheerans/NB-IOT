# Keil uVision project Project.uvprojx, settings and files
target STM32L053R8 (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L053xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\inc;..\src\apps;..\src\system;..\src\boards;..\src\peripherals\adxl362;..\src\peripherals\bh1750fvi;..\src\peripherals\hmc5883l;..\src\peripherals\us100;..\src\peripherals\buzzer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group apps
    ../src/apps/: main.c
  group boards
    ../src/boards/: board.c button_board.c led_board.c
  group system
    ../src/system/: delay.c i2c.c printf.c spi.c uart.c
  group peripherals
    ../src/peripherals/us100/: us100.c
    ../src/peripherals/adxl362/: adxl362.c
    ../src/peripherals/bh1750fvi/: bh1750fvi.c
    ../src/peripherals/hmc5883l/: hmc5883l.c
    ../src/peripherals/buzzer/: buzzer.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.6.0
